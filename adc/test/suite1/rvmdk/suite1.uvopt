<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_opt.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>Debug_Flash</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>8000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>1</RunSim>
        <RunTarget>0</RunTarget>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\lst\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>0</CpuCode>
      <Books>
        <Book>
          <Number>0</Number>
          <Title>Data Sheet</Title>
          <Path>DATASHEETS\Holtek\HT32F125x.pdf</Path>
        </Book>
      </Books>
      <DllOpt>
        <SimDllName>SARMCM3.DLL</SimDllName>
        <SimDllArguments></SimDllArguments>
        <SimDlgDllName>DLM.DLL</SimDlgDllName>
        <SimDlgDllArguments>-pEMBER</SimDlgDllArguments>
        <TargetDllName>SARMCM3.DLL</TargetDllName>
        <TargetDllArguments></TargetDllArguments>
        <TargetDlgDllName>TLM.DLL</TargetDlgDllName>
        <TargetDlgDllArguments>-pEMBER</TargetDlgDllArguments>
      </DllOpt>
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <nTsel>12</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>BIN\holtek-elink32.dll</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGTARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(1007=-1,-1,-1,-1,0)(1008=-1,-1,-1,-1,0)(1009=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>holtek-elink32</Key>
          <Name>setcontext --link-name="e-Link32" --link-clk=500000 --debug-port=0 --reset=2 --ifrun=1 --erase=2 --cache-code=0 --ifverify=0 --con-opt=0 --trace-mode=1 --driver="C:\Keil\ARM\Flash\HT32F_OPT.FLM" --driver="C:\Keil\ARM\Flash\HT32F.FLM"</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>-O207 -S0 -C0 -FO7 -FD20000000 -FC800 -FN2 -FF0HT32F -FS00 -FL07C00 -FF1HT32F_OPT -FS11FF00000 -FL1400)</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <Breakpoint>
        <Bp>
          <Number>0</Number>
          <Type>0</Type>
          <LineNumber>496</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>10358</Address>
          <ByteObject>0</ByteObject>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>1</BreakIfRCount>
          <Filename></Filename>
          <ExecCommand></ExecCommand>
          <Expression>\\SysCtlTest\test\496</Expression>
        </Bp>
        <Bp>
          <Number>1</Number>
          <Type>0</Type>
          <LineNumber>151</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>13566</Address>
          <ByteObject>0</ByteObject>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>1</BreakIfRCount>
          <Filename></Filename>
          <ExecCommand></ExecCommand>
          <Expression>\\SysCtlTest\xadctest02\151</Expression>
        </Bp>
        <Bp>
          <Number>2</Number>
          <Type>0</Type>
          <LineNumber>124</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>13456</Address>
          <ByteObject>0</ByteObject>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>1</BreakIfRCount>
          <Filename></Filename>
          <ExecCommand></ExecCommand>
          <Expression>\\SysCtlTest\xadctest02\124</Expression>
        </Bp>
      </Breakpoint>
      <WatchWindow1>
        <Ww>
          <count>0</count>
          <WinNumber>1</WinNumber>
          <ItemText>ulEventFlags</ItemText>
        </Ww>
      </WatchWindow1>
      <DebugFlag>
        <trace>0</trace>
        <periodic>0</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
      <SystemViewers>
        <Entry>
          <Name>System Viewer\ADC</Name>
          <WinId>35905</WinId>
        </Entry>
      </SystemViewers>
    </TargetOption>
  </Target>

  <Target>
    <TargetName>Debug_Ram</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>12000000</CLKADS>
      <OPTTT>
        <gFlags>0</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>1</RunSim>
        <RunTarget>0</RunTarget>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\lst\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>0</IsCurrentTarget>
      </OPTFL>
      <CpuCode>0</CpuCode>
      <DllOpt>
        <SimDllName>SARMCM3.DLL</SimDllName>
        <SimDllArguments></SimDllArguments>
        <SimDlgDllName>DARMCM1.DLL</SimDlgDllName>
        <SimDlgDllArguments>-pNUC140LE3AN</SimDlgDllArguments>
        <TargetDllName>SARMCM3.DLL</TargetDllName>
        <TargetDllArguments></TargetDllArguments>
        <TargetDlgDllName>TARMCM1.DLL</TargetDlgDllName>
        <TargetDlgDllArguments>-pNUC140LE3AN</TargetDlgDllArguments>
      </DllOpt>
      <DebugOpt>
        <uSim>1</uSim>
        <uTrg>0</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>0</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <nTsel>0</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile>.\ram.ini</tIfile>
        <pMon>BIN\UL2CM3.DLL</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGDARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(1007=-1,-1,-1,-1,0)(1008=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name>-T0</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <DebugFlag>
        <trace>0</trace>
        <periodic>0</periodic>
        <aLwin>0</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>rvmdk</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>156</TopLine>
      <CurrentLine>162</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\startup\src\startup_rvmdk.s</PathWithFileName>
      <FilenameWithoutPath>startup_rvmdk.s</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>libcox</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>994</TopLine>
      <CurrentLine>1004</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xcore.c</PathWithFileName>
      <FilenameWithoutPath>xcore.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>183</TopLine>
      <CurrentLine>183</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xcore.h</PathWithFileName>
      <FilenameWithoutPath>xcore.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>91</TopLine>
      <CurrentLine>91</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xdebug.h</PathWithFileName>
      <FilenameWithoutPath>xdebug.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>5</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>8</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>355</TopLine>
      <CurrentLine>361</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xhw_sysctl.h</PathWithFileName>
      <FilenameWithoutPath>xhw_sysctl.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>6</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>25</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>85</TopLine>
      <CurrentLine>105</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xhw_types.h</PathWithFileName>
      <FilenameWithoutPath>xhw_types.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>7</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>908</TopLine>
      <CurrentLine>920</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xsysctl.c</PathWithFileName>
      <FilenameWithoutPath>xsysctl.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>8</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>8</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>851</TopLine>
      <CurrentLine>854</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xsysctl.h</PathWithFileName>
      <FilenameWithoutPath>xsysctl.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>9</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xhw_nvic.h</PathWithFileName>
      <FilenameWithoutPath>xhw_nvic.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>10</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>17</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>183</TopLine>
      <CurrentLine>198</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xhw_ints.h</PathWithFileName>
      <FilenameWithoutPath>xhw_ints.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>11</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>8</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>119</TopLine>
      <CurrentLine>137</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xhw_memmap.h</PathWithFileName>
      <FilenameWithoutPath>xhw_memmap.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>12</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>960</TopLine>
      <CurrentLine>960</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xgpio.c</PathWithFileName>
      <FilenameWithoutPath>xgpio.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>13</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>20</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1367</TopLine>
      <CurrentLine>1385</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xgpio.h</PathWithFileName>
      <FilenameWithoutPath>xgpio.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>14</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xhw_gpio.h</PathWithFileName>
      <FilenameWithoutPath>xhw_gpio.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>15</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>26</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>647</TopLine>
      <CurrentLine>667</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xhw_uart.h</PathWithFileName>
      <FilenameWithoutPath>xhw_uart.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>16</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>573</TopLine>
      <CurrentLine>573</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xuart.c</PathWithFileName>
      <FilenameWithoutPath>xuart.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>17</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>26</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1659</TopLine>
      <CurrentLine>1670</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xuart.h</PathWithFileName>
      <FilenameWithoutPath>xuart.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>18</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>8</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>261</TopLine>
      <CurrentLine>270</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xhw_adc.h</PathWithFileName>
      <FilenameWithoutPath>xhw_adc.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>19</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>108</TopLine>
      <CurrentLine>120</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xadc.c</PathWithFileName>
      <FilenameWithoutPath>xadc.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>20</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>25</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1106</TopLine>
      <CurrentLine>1122</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\libcox\xadc.h</PathWithFileName>
      <FilenameWithoutPath>xadc.h</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>test</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>21</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1</TopLine>
      <CurrentLine>22</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\testframe\main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>22</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>477</TopLine>
      <CurrentLine>487</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\testframe\test.c</PathWithFileName>
      <FilenameWithoutPath>test.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>23</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>40</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>180</TopLine>
      <CurrentLine>194</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\testframe\test.h</PathWithFileName>
      <FilenameWithoutPath>test.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>24</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>10</TopLine>
      <CurrentLine>18</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\..\testframe\testport.c</PathWithFileName>
      <FilenameWithoutPath>testport.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>source</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
  </Group>

  <Group>
    <GroupName>document</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
  </Group>

  <Group>
    <GroupName>testcase</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>25</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1</TopLine>
      <CurrentLine>27</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\src\testcase.c</PathWithFileName>
      <FilenameWithoutPath>testcase.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>26</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>45</TopLine>
      <CurrentLine>61</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\src\testcase.h</PathWithFileName>
      <FilenameWithoutPath>testcase.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>27</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>414</TopLine>
      <CurrentLine>414</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\src\xadctest00.c</PathWithFileName>
      <FilenameWithoutPath>xadctest00.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>28</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>21</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>103</TopLine>
      <CurrentLine>103</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\src\xadctest01.c</PathWithFileName>
      <FilenameWithoutPath>xadctest01.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>29</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>48</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>37</TopLine>
      <CurrentLine>37</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\src\xadctest02.c</PathWithFileName>
      <FilenameWithoutPath>xadctest02.c</FilenameWithoutPath>
    </File>
  </Group>

  <MDIGroups>
    <Orientation>1</Orientation>
    <ActiveMDIGroup>0</ActiveMDIGroup>
    <MDIGroup>
      <Size>100</Size>
      <ActiveTab>0</ActiveTab>
      <Documents>
        <Doc>
          <Name>..\src\xadctest02.c</Name>
          <ColumnNumber>48</ColumnNumber>
          <TopLine>37</TopLine>
          <CurrentLine>37</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\testframe\main.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>1</TopLine>
          <CurrentLine>22</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\libcox\xhw_adc.h</Name>
          <ColumnNumber>8</ColumnNumber>
          <TopLine>261</TopLine>
          <CurrentLine>270</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\testframe\test.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>477</TopLine>
          <CurrentLine>487</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\libcox\xadc.h</Name>
          <ColumnNumber>25</ColumnNumber>
          <TopLine>1106</TopLine>
          <CurrentLine>1122</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\libcox\xadc.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>108</TopLine>
          <CurrentLine>120</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\src\xadctest00.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>414</TopLine>
          <CurrentLine>414</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\testframe\testport.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>10</TopLine>
          <CurrentLine>18</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\startup\src\startup_rvmdk.s</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>156</TopLine>
          <CurrentLine>162</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\src\testcase.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>1</TopLine>
          <CurrentLine>27</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\src\xadctest01.c</Name>
          <ColumnNumber>21</ColumnNumber>
          <TopLine>103</TopLine>
          <CurrentLine>103</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\src\testcase.h</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>45</TopLine>
          <CurrentLine>61</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\libcox\xsysctl.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>908</TopLine>
          <CurrentLine>920</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\libcox\xsysctl.h</Name>
          <ColumnNumber>8</ColumnNumber>
          <TopLine>851</TopLine>
          <CurrentLine>854</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\libcox\xgpio.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>960</TopLine>
          <CurrentLine>960</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\libcox\xhw_types.h</Name>
          <ColumnNumber>25</ColumnNumber>
          <TopLine>85</TopLine>
          <CurrentLine>105</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\libcox\xhw_memmap.h</Name>
          <ColumnNumber>8</ColumnNumber>
          <TopLine>119</TopLine>
          <CurrentLine>137</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\libcox\xdebug.h</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>91</TopLine>
          <CurrentLine>91</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\libcox\xuart.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>573</TopLine>
          <CurrentLine>573</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\libcox\xgpio.h</Name>
          <ColumnNumber>20</ColumnNumber>
          <TopLine>1367</TopLine>
          <CurrentLine>1385</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\testframe\test.h</Name>
          <ColumnNumber>40</ColumnNumber>
          <TopLine>180</TopLine>
          <CurrentLine>194</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\libcox\xuart.h</Name>
          <ColumnNumber>26</ColumnNumber>
          <TopLine>1659</TopLine>
          <CurrentLine>1670</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\libcox\xcore.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>994</TopLine>
          <CurrentLine>1004</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\libcox\xhw_uart.h</Name>
          <ColumnNumber>26</ColumnNumber>
          <TopLine>526</TopLine>
          <CurrentLine>526</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\libcox\xhw_ints.h</Name>
          <ColumnNumber>17</ColumnNumber>
          <TopLine>183</TopLine>
          <CurrentLine>198</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\libcox\xhw_sysctl.h</Name>
          <ColumnNumber>8</ColumnNumber>
          <TopLine>355</TopLine>
          <CurrentLine>361</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\..\..\libcox\xcore.h</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>173</TopLine>
          <CurrentLine>173</CurrentLine>
        </Doc>
      </Documents>
    </MDIGroup>
  </MDIGroups>

</ProjectOpt>
